# Keil uVision project mb9bf61x.uvproj, settings and files
target Debug (ARM-ADS)
  device: MB9AF102N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20001FFF) IRAM2(0x1FFFE000-0x1FFFFFFF) IROM(0x00000000-0x0001FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: mb9bf61x
  c flags: Optim=1
  c include: ..\..\..\include;..\..\..\include\kernel;..\..\..\include\ksh;..\..\..\include\usb;..\..\..\target\fujitu\mb9bf61x\inc;.\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  group kernel
    ../../../src/kernel/: kos.c kos_arch.c kos_cyc.c kos_dtq.c kos_flg.c kos_inh.c kos_sem.c kos_sys.c kos_tim.c kos_tsk.c kos_vars.c
  group target
    ../../../target/fujitu/mb9bf61x/src/: system_mb9bf61x.c
    ../../../target/fujitu/mb9bf61x/src/arm/: startup_mb9bf61x.s
  group usb
    ../../../src/usb/: usbcdc.c usbdrv.c usbdrvcmn.c usbhdrv.c
  group ksh
    ../../../src/ksh/: ksh.c
  group user
    ./: usr_init.c led_drv.c ksh_usr_cmd.c clib_itm_stub.c target_inthdr.c
