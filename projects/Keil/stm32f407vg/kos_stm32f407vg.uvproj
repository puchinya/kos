# Keil uVision project kos_stm32f407vg.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: kos_stm32f407vg
  c flags: Optim=1
  c include: ..\..\..\include\kernel;..\..\..\target\stmicro\stm32f4xx\inc;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group kernel
    ../../../src/kernel/: kos.c kos_arch.c kos_cyc.c kos_dtq.c kos_flg.c kos_inh.c kos_sem.c kos_sys.c kos_tim.c kos_tsk.c kos_vars.c
  group target
    ../../../target/stmicro/stm32f4xx/src/: system_stm32f4xx.c
    ../../../target/stmicro/stm32f4xx/src/asm/arm/: startup_stm32f4xx.s
  group user
    ./: clib_itm_stub.c usr_init.c target_inthdr.c
