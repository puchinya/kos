# Keil uVision project fm3_usb_proj.uvproj, settings and files
target Debug (ARM-ADS)
  device: MB9AF102N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20001FFF) IRAM2(0x1FFFE000-0x1FFFFFFF) IROM(0x00000000-0x0001FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: fm3_usb_proj +hex
  c flags: Optim=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  group Source
    ./src/: system_mb9bf61x.c startup_mb9bf61x.s main.c usbdrv.c usbcdc.c kos.c ksh.c ksh_usr_cmd.c led_drv.c kos_arch.c kos_sem.c kos_flg.c kos_cyc.c kos_tsk.c kos_tim.c kos_vars.c clib_itm_stub.c
    ./include/: kos.h
